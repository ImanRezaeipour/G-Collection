# IAR project GP.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2378 Philips LPC2378
  ICCARM.CCDefines: DEBUG=1; OS_UART=-1; IAR_LPC_2378_SK; __cplusplus
  ICCARM.CCIncludePath2: inc\ip\; inc\fs\; inc\os\; inc\usb\; inc\; Classes\; mci\inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: GP.hex
  ILINK.IlinkOutputFile: GP.out
  ILINK.IlinkIcfFile: Setup\LPC2378_RAM.icf
  ILINK.IlinkExtraOptions: --redirect __write=__write_buffered
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2388 NXP LPC2388
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: GP.icf
configuration Release_FLASH (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2388 NXP LPC2388
  ICCARM.CCDefines: IAR_LPC_2378_SK; __cplusplus
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: GP.icf
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Main.cpp
  group Classes & Headers
    Classes/: Alarm.cpp Alarm.h BackLight.cpp BackLight.h Beep.cpp Beep.h Buffer.cpp BUFFER.H Coding.cpp Coding.h COM.cpp COM.H Communication.cpp Communication.h CommunicationPacket.cpp CommunicationPacket.h Control.Cpp CONTROL.H DAC.cpp DAC.h DATATYPE.H DateTime.cpp DateTime.h Device.cpp Device.h DigitalData.cpp DIGITALDATA.H Finger.cpp Finger.h FingerPacket.cpp FINGERPACKET.H Font.cpp Font.h Font2.cpp Font2.h Hardware.cpp HARDWARE.H HResource.cpp HResource.h Key.cpp Key.h LCD.cpp LCD.H LED.cpp LED.h Menu.cpp MENU.H Mifare.cpp Mifare.h MifareEx.cpp MifareEx.h MifarePacket.cpp MifarePacket.h MResource.cpp MResource.h MY_USB.cpp MY_USB.h Network.cpp NETWORK.H Notify.cpp Notify.H Packet.cpp PACKET.H Personal.cpp PERSONAL.H Setting.cpp Setting.h ShowTime.CPP SHOWTIME.H Sound.cpp Sound.h Status.cpp Status.h Utility.cpp Utility.h View.cpp View.h
    Setup/: DataType.h
  group Data
    Classes/: Font.d Sound.d
  group Lib
    $EW_DIR$/arm/PowerPac/FileSystem/Lib/: fs4t_al__dn.a fs4t_al__ds.a fs4t_al__rs.a
    $EW_DIR$/arm/PowerPac/TCPIP/Lib/: ip4t_al__d.a ip4t_al__r.a
    $EW_DIR$/arm/PowerPac/RTOS/Lib/: os4t_al__d.a os4t_al__r.a
    $EW_DIR$/arm/PowerPac/USB/Lib/: usb4t_al__d.a usb4t_al__r.a
  group Setup
    Setup/: BSP.c FS_ConfigIO.c FS_ConfigMMC_MCI.c FS_MMC_HW_MCI.c FS_OS.c IP_Config_LPC23xx.c IP_ConfigIO.c IP_OS.c JLINKDCC_ProcessV2.c OS_Error.c RTOSINIT_LPC2378.c target.c USB_Config_LPC2378.c USB_OS.c
